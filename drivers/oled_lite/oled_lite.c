/* SPDX-License-Identifier: Apache-2.0 */
#include "oled_lite.h"
#include "shared_i2c.h"
#include <errno.h>
#include <string.h>
#include <zephyr/drivers/i2c.h>

#define WIDTH 128U
#define HEIGHT 64U
#define OLED_ADDR 0x3c
static const struct device *const bus = DEVICE_DT_GET(DT_NODELABEL(i2c1));
static uint8_t framebuffer[HEIGHT / 8][WIDTH];
BUILD_ASSERT(sizeof(framebuffer) <= 1024);

static void pixel(unsigned int x, unsigned int y, bool on)
{
	uint8_t *byte = &framebuffer[y / 8][x];
	WRITE_BIT(*byte, y % 8, on);
}

void oled_lite_clear(void)
{
	k_mutex_lock(&bias_i2c1_mutex, K_FOREVER);
	memset(framebuffer, 0, sizeof(framebuffer));
	k_mutex_unlock(&bias_i2c1_mutex);
}

int oled_lite_pixel(unsigned int x, unsigned int y, bool on)
{
	if (x >= WIDTH || y >= HEIGHT) {
		return -ERANGE;
	}
	k_mutex_lock(&bias_i2c1_mutex, K_FOREVER);
	pixel(x, y, on);
	k_mutex_unlock(&bias_i2c1_mutex);
	return 0;
}

/* Each row holds the five left-to-right pixel bits (bits 4..0) for one scanline. */
static const uint8_t glyphs[][7] = {
	['0' - ' '] = { 0x0E, 0x11, 0x13, 0x15, 0x19, 0x11, 0x0E },
	['1' - ' '] = { 0x04, 0x0C, 0x04, 0x04, 0x04, 0x04, 0x0E },
	['2' - ' '] = { 0x0E, 0x11, 0x01, 0x02, 0x04, 0x08, 0x1F },
	['3' - ' '] = { 0x1F, 0x02, 0x04, 0x02, 0x01, 0x11, 0x0E },
	['4' - ' '] = { 0x02, 0x06, 0x0A, 0x12, 0x1F, 0x02, 0x02 },
	['5' - ' '] = { 0x1F, 0x10, 0x1E, 0x01, 0x01, 0x11, 0x0E },
	['6' - ' '] = { 0x06, 0x08, 0x10, 0x1E, 0x11, 0x11, 0x0E },
	['7' - ' '] = { 0x1F, 0x01, 0x02, 0x04, 0x08, 0x08, 0x08 },
	['8' - ' '] = { 0x0E, 0x11, 0x11, 0x0E, 0x11, 0x11, 0x0E },
	['9' - ' '] = { 0x0E, 0x11, 0x11, 0x0F, 0x01, 0x02, 0x0C },
	['A' - ' '] = { 0x0E, 0x11, 0x11, 0x1F, 0x11, 0x11, 0x11 },
	['B' - ' '] = { 0x1E, 0x11, 0x11, 0x1E, 0x11, 0x11, 0x1E },
	['C' - ' '] = { 0x0E, 0x11, 0x10, 0x10, 0x10, 0x11, 0x0E },
	['D' - ' '] = { 0x1C, 0x12, 0x11, 0x11, 0x11, 0x12, 0x1C },
	['E' - ' '] = { 0x1F, 0x10, 0x10, 0x1E, 0x10, 0x10, 0x1F },
	['F' - ' '] = { 0x1F, 0x10, 0x10, 0x1E, 0x10, 0x10, 0x10 },
	['G' - ' '] = { 0x0E, 0x11, 0x10, 0x17, 0x11, 0x11, 0x0F },
	['H' - ' '] = { 0x11, 0x11, 0x11, 0x1F, 0x11, 0x11, 0x11 },
	['I' - ' '] = { 0x0E, 0x04, 0x04, 0x04, 0x04, 0x04, 0x0E },
	['J' - ' '] = { 0x07, 0x02, 0x02, 0x02, 0x02, 0x12, 0x0C },
	['K' - ' '] = { 0x11, 0x12, 0x14, 0x18, 0x14, 0x12, 0x11 },
	['L' - ' '] = { 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x1F },
	['M' - ' '] = { 0x11, 0x1B, 0x15, 0x15, 0x11, 0x11, 0x11 },
	['N' - ' '] = { 0x11, 0x11, 0x19, 0x15, 0x13, 0x11, 0x11 },
	['O' - ' '] = { 0x0E, 0x11, 0x11, 0x11, 0x11, 0x11, 0x0E },
	['P' - ' '] = { 0x1E, 0x11, 0x11, 0x1E, 0x10, 0x10, 0x10 },
	['Q' - ' '] = { 0x0E, 0x11, 0x11, 0x11, 0x15, 0x12, 0x0D },
	['R' - ' '] = { 0x1E, 0x11, 0x11, 0x1E, 0x14, 0x12, 0x11 },
	['S' - ' '] = { 0x0F, 0x10, 0x10, 0x0E, 0x01, 0x01, 0x1E },
	['T' - ' '] = { 0x1F, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04 },
	['U' - ' '] = { 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x0E },
	['V' - ' '] = { 0x11, 0x11, 0x11, 0x11, 0x11, 0x0A, 0x04 },
	['W' - ' '] = { 0x11, 0x11, 0x11, 0x15, 0x15, 0x15, 0x0A },
	['X' - ' '] = { 0x11, 0x11, 0x0A, 0x04, 0x0A, 0x11, 0x11 },
	['Y' - ' '] = { 0x11, 0x11, 0x0A, 0x04, 0x04, 0x04, 0x04 },
	['Z' - ' '] = { 0x1F, 0x01, 0x02, 0x04, 0x08, 0x10, 0x1F },
	['-' - ' '] = { 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00 },
	['.' - ' '] = { 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x0C },
	[':' - ' '] = { 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x0C, 0x00 },
	[' ' - ' '] = { 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00 },
};

static unsigned char uppercase(unsigned char c)
{
	return c >= 'a' && c <= 'z' ? c - 'a' + 'A' : c;
}

static bool is_supported_char(unsigned char c)
{
	return (c >= '0' && c <= '9') || (c >= 'A' && c <= 'Z') ||
	       c == ' ' || c == '-' || c == '.' || c == ':';
}

int oled_lite_text(unsigned int x, unsigned int y, const char *text)
{
	if (!text) {
		return -EINVAL;
	}
	if (x > WIDTH || y > HEIGHT - 8U || strlen(text) > (WIDTH - x) / 6U) {
		return -ERANGE;
	}
	for (const char *p = text; *p; ++p) {
		if (!is_supported_char(uppercase((unsigned char)*p))) {
			return -ENOTSUP;
		}
	}
	k_mutex_lock(&bias_i2c1_mutex, K_FOREVER);
	for (; *text; ++text, x += 6U) {
		const uint8_t *rows = glyphs[uppercase((unsigned char)*text) - ' '];
		for (unsigned int row = 0; row < 8U; ++row) {
			for (unsigned int col = 0; col < 6U; ++col) {
				pixel(x + col, y + row, row < 7U && col < 5U &&
				      (rows[row] & BIT(4U - col)));
			}
		}
	}
	k_mutex_unlock(&bias_i2c1_mutex);
	return 0;
}

/* SSD1306 horizontal addressing. Keep the control byte and its data in
 * one I2C write, including on controllers that cannot concatenate messages.
 */
static int flush_locked(void)
{
	static const uint8_t window[] = { 0, 0x21, 0, WIDTH - 1, 0x22, 0, HEIGHT / 8 - 1 };
	uint8_t packet[1 + WIDTH] = { 0x40 };
	int rc = i2c_write(bus, window, sizeof(window), OLED_ADDR);

	for (size_t page = 0; !rc && page < ARRAY_SIZE(framebuffer); ++page) {
		memcpy(packet + 1, framebuffer[page], WIDTH);
		rc = i2c_write(bus, packet, sizeof(packet), OLED_ADDR);
	}
	return rc;
}

int oled_lite_flush(void)
{
	if (!device_is_ready(bus)) {
		return -ENODEV;
	}
	k_mutex_lock(&bias_i2c1_mutex, K_FOREVER);
	int rc = flush_locked();
	k_mutex_unlock(&bias_i2c1_mutex);
	return rc;
}

int oled_lite_init(void)
{
	static const uint8_t setup[] = {
		0, 0xae, 0xd5, 0x80, 0xa8, HEIGHT - 1, 0xd3, 0, 0x40,
		0x8d, 0x14, 0x20, 0, 0xa1, 0xc8, 0xda, 0x12,
		0x81, 0x7f, 0xd9, 0xf1, 0xdb, 0x40, 0xa4, 0xa6,
	};
	static const uint8_t display_on[] = { 0, 0xaf };

	if (!device_is_ready(bus)) {
		return -ENODEV;
	}
	k_mutex_lock(&bias_i2c1_mutex, K_FOREVER);
	int rc = i2c_write(bus, setup, sizeof(setup), OLED_ADDR);
	if (!rc) {
		memset(framebuffer, 0, sizeof(framebuffer));
		rc = flush_locked();
	}
	if (!rc) {
		rc = i2c_write(bus, display_on, sizeof(display_on), OLED_ADDR);
	}
	k_mutex_unlock(&bias_i2c1_mutex);
	return rc;
}
